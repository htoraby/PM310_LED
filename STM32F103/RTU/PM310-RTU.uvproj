# Keil uVision project PM310-RTU.uvproj, settings and files
target PM310-RTU (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PM310-RTU +hex
  AfterMake: fromelf --bin --output .\PM310-RTU.bin ..\..\debug\STM32F103\PM310\PM310-RTU.axf
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Lib\CMSIS\CM3\CoreSupport;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Lib\STM32F10x_StdPeriph_Driver\inc;..\..\;..\..\DMR\DMRXXX\NPS7510;..\RTU;..\Pub
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x3d000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group STLib
    ../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ../Pub/: STM32F103VC.c STM32_I2CSim1.c STM32_I2CSim2.c STM32_SCI.c
    ./: HDIFNPS7510.c
    ../../PUB/: __Alarm.c __AlarmCTPT.c __Data.c __DevSet.c __DFT.c __Edit.c __Event.c __HZ12x12.c __HZ16x16.c __Key.c __LCD.c __LCDMem.c __Main.c __Measure.c __Output.c __PQPhQh.c __Switch.c __Time.c __Tool.c __WaveRecord.c MyMenu.c MyPage.c MyProtocol.c MyProtocolMODBUS.c MyTable.c
    ../../DMR/PUB/: __Protect.c MyApp.c MyHMIDMR.c MyMenu160x160.c MyPage160x160.c MyPG_Protect.c MyPG_WaveRecord.c MyTableDMR.c
    ../../DMR/DMRXXX/NPS7510/: _MyAppNPS7510.c _MyHMINPS7510.c MyMenuNPS7510.c MyPageNPS7510.c MyPG_ProtectNPS7510.c Protect.c
    ../../HDLIB/: SST25VF016B.c ArEEPROM_FM24CLXX.c MyLCD_UC1698U.c RTC_RX8025.c
